# Keil uVision project empty_LP_MSPM0G3507_nortos_keil.uvprojx, settings and files
target empty_LP_MSPM0G3507_nortos_keil (6240000::V6.24::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty_LP_MSPM0G3507_nortos_keil +hex
  BeforeMake: cmd.exe /C "C:\ti\mspm0_sdk_2_02_00_05\tools\keil\syscfg.bat '$P' empty.syscfg"
  AfterMake: .\align.bat
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __MSPM0G3507__
  c include: ..;..\BSP;..\APP;..\BSP\OLED;..\BSP\bsp_ir_eight;..\BSP\Motor;..\BSP\task;..\BSP\ultrasonic;..\BSP\kalman;..\BSP\MPU6050;..\BSP\eMPL;..\..\source;..\..\source\third_party\CMSIS\Core\Include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: .\mspm0g3507.sct
  link misc: --pad=8
  group Source
    ../: empty.syscfg ti_msp_dl_config.h ti_msp_dl_config.c main.c
    ./: startup_mspm0g350x_uvision.s
    ../BSP/: AllHeader.h config.h
  group Driverlib
    ../ti/: dl_adc12.c dl_aes.c dl_aesadv.c dl_common.c dl_crc.c dl_crcp.c dl_dac12.c dl_dma.c dl_flashctl.c dl_i2c.c dl_keystorectl.c dl_lcd.c dl_lfss.c dl_mathacl.c dl_mcan.c dl_opa.c dl_rtc_common.c dl_spi.c dl_sysctl_mspm0g1x0x_g3x0x.c dl_timer.c dl_trng.c dl_uart.c dl_vref.c
  group BSP
    ../BSP/: delay.c delay.h key.c key.h uart0.c uart0.h bsp.c bsp.h bsp_timer.c bsp_timer.h bsp_beep_led.c bsp_beep_led.h
  group Motor
    ../BSP/Motor/: bsp_motor.c bsp_motor.h bsp_encoder.c bsp_encoder.h
  group OLED
    ../BSP/OLED/: oled.c oled.h oledfont.h
  group task
    ../BSP/task/: task.c task.h
  group ultrasonic
    ../BSP/ultrasonic/: bsp_ultrasonic.c bsp_ultrasonic.h
  group APP
    ../APP/: app_motor.c app_motor.h bsp_PID_motor.c bsp_PID_motor.h app_irtracking_eight.c app_irtracking_eight.h app_straight_yaw.c app_straight_yaw.h My_motor_pid.c My_motor_pid.h
  group kalman
    ../BSP/kalman/: kalman.c kalman.h
  group bsp_ir_eight
    ../BSP/bsp_ir_eight/: bsp_ir_eight.c bsp_ir_eight.h
  group MPU6050
    ../BSP/MPU6050/: bsp_mpu6050.c bsp_mpu6050.h get_mpu6050.c get_mpu6050.h
  group eMPL
    ../BSP/eMPL/: dmpKey.h dmpmap.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h
